# Keil uVision project stm32_iot_terminal.uvprojx, settings and files
target iot_terminal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_iot_terminal +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --locale=english
  c include: ..\Core\Include;..\HalLib\Inc;..\Middleware;..\App;..\Module;..\Module\drv_beep;..\Module\drv_dma;..\Module\drv_led;..\Module\drv_tim7;..\Module\drv_uart1;..\Core\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Core/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Core
    ../Core/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group HalLib
    ../HalLib/Src/: stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Module
    ../Module/drv_beep/: drv_beep.c
    ../Module/drv_dma/: drv_dma.c
    ../Module/drv_led/: drv_led.c
    ../Module/drv_tim7/: drv_tim7.c
    ../Module/drv_uart1/: drv_uart1.c
  group App
    ./: app_config.c main.c stm32f4xx_it.c
