# Keil uVision project IoT_Collector_F407.uvprojx, settings and files
target IoT_Collector_F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08020000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IoT_Collector_F407 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --locale=english --diag_suppress=2803
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS\include;..\Platform\drv_led;..\Platform\drv_eth;..\Platform\drv_uart;..\Platform\drv_flash;..\Platform\drv_lcd;..\FwUpgrade;..\FwUpgrade\ymodem;..\Tools\cm_backtrace;..\LwIP\include;..\LwIP\include\compat;..\LwIP\include\lwip;..\LwIP\include\netif;..\LwIP\include\lwip\apps;..\LwIP\include\lwip\priv;..\LwIP\include\lwip\prot;..\Platform\port;..\MQTT;..\cJSON;..\Platform\drv_dht11;..\Tools\dwt_delay;..\Config;..\OSAL;..\Tools;..\App;..\Platform;..\Components;..\Components\mqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group USER
    ../App/: stm32f4xx_it.c board.c main.c
    ../Platform/drv_led/: bsp_led.c
    ../Platform/drv_uart/: bsp_debug_usart.c bsp_upgrade_usart.c
    ../Platform/drv_flash/: drv_flash.c
    ../FwUpgrade/: fw_upgrade.c
    ../FwUpgrade/ymodem/: ymodem_recv.c ymodem_send.c
    ../Platform/drv_eth/: bsp_eth.c
    ../Config/: FreeRTOSConfig.h
    ../Platform/drv_dht11/: bsp_dht11.c
    ../Tools/dwt_delay/: core_delay.c
    ../Components/mqtt/: mqttclient.c onenet_token.c
    ../Tools/: md5.c debug.c
    ../OSAL/: osal.c
    ../Platform/: drv_manager.c drv_led.c drv_sensor.c drv_camera.c drv_lcd.c drv_key.c
    ../Platform/drv_adc/: drv_adc.c
    ../Platform/drv_ap3216c/: bsp_ap3216c.c
    ../Platform/drv_lcd/: bsp_nt35510_lcd.c fonts.c
    ../Components/: sensor_manager.c cloud_manager.c net_manager.c ota_manager.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group LwIP/api
    ../LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../LwIP/netif/: ethernet.c lowpan6.c lowpan6_ble.c bridgeif.c lowpan6_common.c zepif.c
  group LwIP/arch
    ../Platform/port/: ethernetif.c sys_arch.c
  group MQTT
    ../MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c
  group cJSON
    ../cJSON/: cJSON.c cJSON_Utils.c cJSON_Process.c
  group cm_backtrace
    ../Tools/cm_backtrace/: cm_backtrace.c
    ../Tools/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group DOC
    ../Doc/: readme.txt
